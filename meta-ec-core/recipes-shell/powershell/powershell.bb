DESCRIPTION = ""
PN = "powershell"
PV = "1"

DEPENDS += "wsl"
