DESCRIPTION = "PowerShell Core"
PN = "pwsh"
PV = "1"

DEPENDS += "powershell"

do_install() {
    # use winget
}

do_configure() {

}
