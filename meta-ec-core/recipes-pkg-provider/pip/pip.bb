inherit pkg_provider