DESCRIPTION = ""
PN = "exa"
PV = "1"

EC_DEPRECATED = "Exa is not maintained anymore. Use Eza instead."

inherit installable
