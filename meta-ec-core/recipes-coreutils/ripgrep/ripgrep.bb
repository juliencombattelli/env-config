DESCRIPTION = ""
PN = "ripgrep"
PV = "1"

inherit installable
