DESCRIPTION = ""
PN = "fd"
PV = "1"

inherit installable
