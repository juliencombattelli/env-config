DESCRIPTION = "A simple man page generator"
PN = "scdoc"
PV = "1"

inherit installable
