DESCRIPTION = ""
PN = "gdb"
PV = "1"

inherit installable