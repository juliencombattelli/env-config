DESCRIPTION = ""
PN = "gcc"
PV = "1"

inherit installable