DESCRIPTION = ""
PN = "clang"
PV = "1"

PKG_PROVIDER_apt_PACKAGE_PATTERN_${PN} = "clang-[0-9.]+"

inherit installable