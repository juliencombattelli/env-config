DESCRIPTION = ""
PN = "openssh-server"
PV = "1"

inherit installable

# TODO add empty .ssh/config (to be appended by other meta-layers)