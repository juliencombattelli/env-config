DESCRIPTION = ""
PN = "ssh-server"
PV = "1"

inherit installable