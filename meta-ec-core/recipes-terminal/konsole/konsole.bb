DESCRIPTION = ""
PN = "konsole"
PV = "1"