DESCRIPTION = ""
PN = "libfuse2"
PV = "1"

inherit installable
