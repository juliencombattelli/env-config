do_register_for_installation[noexec] = "1"
do_fetch[noexec] = "1"
do_compile[noexec] = "1"
do_install[noexec] = "1"