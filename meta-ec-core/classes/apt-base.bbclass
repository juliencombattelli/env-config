inherit base


APT_INSTALL_SCRIPT_LOCKFILE = "${TMPDIR}/apt-install-script.lock"
APT_INSTALL_SCRIPT_LOCATION = "${DEPLOY_DIR}/install-apt-packages.sh"
